options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: transceiver_OQPSK
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: IEEE 802.15.4 Transceiver using OQPSK PHY
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[str(i) for i in range(11, 27)]'
    num_opts: '0'
    options: '[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]'
    type: real
    value: '2480000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/sensor.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Hello World!\n")
    period: '20'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: |
      pmt.cons(
          pmt.make_dict(),
          pmt.init_u8vector(len(b"HELLO WORLD"), list(b"HELLO WORLD"))
      )
    period: '500'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: convert_ascii
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import numpy as np
      from gnuradio import gr
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="pdu_to_text", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle)
              self.message_port_register_out(pmt.intern("out"))

          def handle(self, msg):
              # msg is a PDU: (meta . u8vector)
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)

              # convert u8vector -> Python bytes
              data = bytes(pmt.u8vector_elements(vec))

              # try decode as UTF-8/ASCII
              try:
                  text = data.decode("utf-8", errors="replace")
              except Exception:
                  text = str(data)

              print("RX TEXT:", text)
              self.message_port_pub(pmt.intern("out"), msg)
  states: {}
- name: digital_crc16_async_bb_0
  id: digital_crc16_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc16_async_bb_1
  id: digital_crc16_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='seq_pdu',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle)
              self.message_port_register_out(pmt.intern("out"))
              self.seq = 0


          def handle(self, msg):
              self.seq += 1
              s = f"{self.seq:06d} HELLO WORLD"
              payload = pmt.init_u8vector(len(s.encode()), list(s.encode()))
              pdu = pmt.cons(pmt.make_dict(), payload)
              self.message_port_pub(pmt.intern("out"), pdu)
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'True'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: 2**16
    pad_front: '1000'
    pad_tail: '1000'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {state: disabled}
- name: ieee802_15_4_mac_0
  id: ieee802_15_4_mac
  parameters:
    debug: 'True'
    dst: '0xffff'
    dst_pan: '0x1aaa'
    fcf: '0x8841'
    seq_nr: '0'
    src: '0x3344'
  states: {state: disabled}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: ieee802_15_4_rime_stack_0
  id: ieee802_15_4_rime_stack
  parameters:
    bc_channels: '[129]'
    rime_add: '[23,42]'
    ruc_channels: '[132]'
    uc_channels: '[131]'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'you can connect to the Socket PDU with: ''nc -u localhost 52002'''
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("system_time")
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '20'
    minsize: '10'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e3
    fc: '0'
    fftsize: '1024'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 1e6
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: 4e6
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.7"'
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: '200000'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: '200000'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: '0.7'
    gain_type0: normalized
    samp_rate: 1e6
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, epy_block_0, in]
- [blocks_message_strobe_0, strobe, ieee802_15_4_rime_stack_0, bcin]
- [blocks_message_strobe_1, strobe, epy_block_0, in]
- [blocks_message_strobe_1, strobe, pdu_random_pdu_0, generate]
- [digital_crc16_async_bb_0, out, ieee802_15_4_oqpsk_phy_0, txin]
- [digital_crc16_async_bb_1, out, convert_ascii, in]
- [epy_block_0, out, pdu_add_system_time_0, pdu]
- [foo_packet_pad2_0, '0', blocks_tag_debug_0, '0']
- [foo_packet_pad2_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_mac_0, app out, ieee802_15_4_rime_stack_0, fromMAC]
- [ieee802_15_4_mac_0, pdu out, foo_wireshark_connector_0, in]
- [ieee802_15_4_mac_0, pdu out, ieee802_15_4_oqpsk_phy_0, txin]
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', qtgui_freq_sink_x_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', qtgui_time_sink_x_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', uhd_usrp_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, digital_crc16_async_bb_1, in]
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [ieee802_15_4_oqpsk_phy_0, rxout, ieee802_15_4_mac_0, pdu in]
- [ieee802_15_4_rime_stack_0, toMAC, ieee802_15_4_mac_0, app in]
- [pdu_add_system_time_0, pdu, digital_crc16_async_bb_0, in]
- [pdu_random_pdu_0, pdus, pdu_add_system_time_0, pdu]
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
