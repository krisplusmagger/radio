options:
  parameters:
    generate_options: qt_gui
    id: wifi_tx_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[4890000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5920000000'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["2 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[2e6, 10e6, 20e6]'
    type: real
    value: 2e6
  states: {}
- name: samp_rate_zig
  id: variable_qtgui_chooser
  parameters:
    labels: '["200KHz", "400 KHz", "800 KHz"]'
    num_opts: '0'
    options: '[2e5, 4e5, 8e5]'
    type: real
    value: 2e5
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: tx_gain_zig
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {state: disabled}
- name: convert_ascii
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import numpy as np
      from gnuradio import gr
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="pdu_to_text", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle)
              self.message_port_register_out(pmt.intern("out"))

          def handle(self, msg):
              # msg is a PDU: (meta . u8vector)
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)

              # convert u8vector -> Python bytes
              data = bytes(pmt.u8vector_elements(vec))

              # try decode as UTF-8/ASCII
              try:
                  text = data.decode("utf-8", errors="replace")
              except Exception:
                  text = str(data)

              print("RX TEXT:", text)
              self.message_port_pub(pmt.intern("out"), msg)
  states: {state: disabled}
- name: convert_ascii_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import numpy as np
      from gnuradio import gr
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="pdu_to_text", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle)
              self.message_port_register_out(pmt.intern("out"))

          def handle(self, msg):
              # msg is a PDU: (meta . u8vector)
              meta = pmt.car(msg)
              vec  = pmt.cdr(msg)

              # convert u8vector -> Python bytes
              data = bytes(pmt.u8vector_elements(vec))

              # try decode as UTF-8/ASCII
              try:
                  text = data.decode("utf-8", errors="replace")
              except Exception:
                  text = str(data)

              print("RX TEXT:", text)
              self.message_port_pub(pmt.intern("out"), msg)
  states: {}
- name: digital_crc16_async_bb_0
  id: digital_crc16_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc16_async_bb_1
  id: digital_crc16_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: '100000'
    pad_front: '10000'
    pad_tail: '10000'
  states: {state: disabled}
- name: foo_packet_pad2_1
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '5'
    pad_tail: '0'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("system_time")
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: seq_input
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import time


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="seq_pdu", in_sig=None, out_sig=None)

              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_trigger)
              self.message_port_register_in(pmt.intern("feedback"))
              self.set_msg_handler(pmt.intern("feedback"), self.handle_feedback)
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("zigbee_out"))

              self.max_seq = 1000000
              self.seq = 0
              self.current_payload = None  # current_payload will set after first message from in port
              self.stopped = False
              self.total_tx_count = 0
              self.ack_count = 0
              self.nack_count = 0
              self.tx_payload_bytes = 0
              self.acked_payload_bytes = 0
              self.start_time = None
              self.end_time = None
              self.stats_filename = "seq_pdu_stats.txt"

          def handle_trigger(self, msg):
              if self.stopped or self.current_payload is not None:
                  return

              self.seq += 1
              self.current_payload = self.build_payload(self.seq)
              self.publish_current_payload()

          def handle_feedback(self, msg):
              if self.current_payload is None:
                  return

              if not pmt.is_symbol(msg):
                  return

              feedback = pmt.symbol_to_string(msg)

              if feedback == "ack":
                  self.ack_count += 1
                  self.acked_payload_bytes += len(self.current_payload)
                  if self.seq >= self.max_seq:
                      self.current_payload = None
                      self.stopped = True
                      self.end_time = time.monotonic()
                      self.write_stats()
                      return
                  self.seq += 1
                  self.current_payload = self.build_payload(self.seq)
                  self.publish_current_payload()
              elif feedback == "nack":
                  self.nack_count += 1
                  self.publish_current_payload()

          def build_payload(self, seq):
              return f"{seq:06d} HELLO WORLD".encode()

          def publish_current_payload(self):
              if self.start_time is None:
                  self.start_time = time.monotonic()

              payload = pmt.init_u8vector(len(self.current_payload), list(self.current_payload))
              pdu = pmt.cons(pmt.make_dict(), payload)
              self.message_port_pub(pmt.intern("out"), pdu)

              zigbee_payload = b"000001 HELLO WORLD"
              zigbee_pdu = pmt.cons(
                  pmt.make_dict(),
                  pmt.init_u8vector(len(zigbee_payload), list(zigbee_payload)),
              )
              self.message_port_pub(pmt.intern("zigbee_out"), zigbee_pdu)

              self.total_tx_count += 1
              self.tx_payload_bytes += len(self.current_payload)
              self.write_stats()

          def write_stats(self):
              now = self.end_time if self.end_time is not None else time.monotonic()
              elapsed_seconds = 0.0 if self.start_time is None else now - self.start_time
              throughput_bps = (
                  self.acked_payload_bytes * 8 / elapsed_seconds
                  if elapsed_seconds > 0
                  else 0.0
              )
              # tx_rate_bps = (
              #     self.tx_payload_bytes * 8 / elapsed_seconds
              #     if elapsed_seconds > 0
              #     else 0.0
              # )

              with open(self.stats_filename, "w", encoding="ascii") as stats_file:
                  stats_file.write(f"current_seq={self.seq:06d}\n")
                  stats_file.write(f"max_seq={self.max_seq:06d}\n")
                  stats_file.write(f"stopped={int(self.stopped)}\n")
                  stats_file.write(f"total_tx_count={self.total_tx_count}\n")
                  stats_file.write(f"ack_count={self.ack_count}\n")
                  stats_file.write(f"nack_count={self.nack_count}\n")
                  stats_file.write(f"tx_payload_bytes={self.tx_payload_bytes}\n")
                  stats_file.write(f"acked_payload_bytes={self.acked_payload_bytes}\n")
                  stats_file.write(f"elapsed_seconds={elapsed_seconds:.6f}\n")
                  stats_file.write(f"throughput_bps={throughput_bps:.3f}\n")
                  # stats_file.write(f"tx_rate_bps={tx_rate_bps:.3f}\n")
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.7"'
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.3"'
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate_zig
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: chan_est
    encoding: encoding
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: wifi_tx
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    dev_addr: '"addr=192.168.10.6"'
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zigbee_tx
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
    gain0: tx_gain_zig
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: samp_rate_zig
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, seq_input, in]
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [digital_crc16_async_bb_0, out, ieee802_15_4_oqpsk_phy_0, txin]
- [digital_crc16_async_bb_1, out, convert_ascii, in]
- [digital_crc32_async_bb_0, out, wifi_phy_hier_0, mac_in]
- [foo_packet_pad2_0, '0', wifi_phy_hier_0, '0']
- [foo_packet_pad2_1, '0', zigbee_tx, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', foo_packet_pad2_1, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, digital_crc16_async_bb_1, in]
- [pdu_add_system_time_0, pdu, digital_crc16_async_bb_0, in]
- [pdu_add_system_time_0, pdu, digital_crc32_async_bb_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [seq_input, zigbee_out, digital_crc16_async_bb_0, in]
- [seq_input, out, digital_crc32_async_bb_0, in]
- [seq_input, out, pdu_add_system_time_0, pdu]
- [uhd_usrp_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']
- [uhd_usrp_source_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0, '0']
- [wifi_phy_hier_0, '0', qtgui_time_sink_x_0, '0']
- [wifi_phy_hier_0, '0', wifi_tx, '0']
- [wifi_phy_hier_0, mac_out, blocks_message_debug_0, print]
- [wifi_phy_hier_0, mac_out, convert_ascii_0, in]
- [wifi_phy_hier_0, tx_feedback, blocks_message_debug_1, print]
- [wifi_phy_hier_0, tx_feedback, seq_input, feedback]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
